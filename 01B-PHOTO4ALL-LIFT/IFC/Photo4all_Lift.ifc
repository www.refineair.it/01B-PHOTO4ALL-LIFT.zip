Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture]
File name: 0001
Time: 2023-05-23T15:26:54
Author: Iperboole srl, info@iperboole.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.50.27 - Exporter 21.2.1.0 - Alternate UI 21.2.1.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 23 15:26:54 2023 * Host: DESKTOP-EF0D6F5 * Database: C:\Users\FRANCE~1\AppData\Local\Temp\9cfa61fd-fc0a-459d-8ab3-0ce2c6f543f3\e7ae7d4e-7334-4835-a441-fe667d007de1\ifc * Database version: 5507 * Database creation date: Tue May 23 15:26:53 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 23 15:26:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 23 15:26:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Refineair-Mockup

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Maggio 2023; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Refineair; Nome del progetto: Refineair-Mockup; Numero del progetto: 0001
Dati identità - Autore: Iperboole srl

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Maggio 2023; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Refineair; Nome del progetto: Refineair-Mockup; Numero del progetto: 0001
Dati identità - Autore: Iperboole srl

# IfcBuildingStorey: Livello:Estremità 8 mm, Livello 1
LongName: Livello 1; Elevation: 0 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Altro - Categoria: Livelli; Famiglia: Livello: Estremità 8 mm; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: Livello: Estremità 8 mm; Tipo: Livello: Estremità 8 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 mm
Vincoli - Quota altimetrica: 0 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Estremità 8 mm
Grafica(Type) - Colore: 0; Modello di linea: Centro (2); Simbolo: M_Estremità del livello - Cerchio: M_Estremità del livello - Cerchio; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcEnergyConversionDevice: AM-Photo4all_Lift:AM-Photo4all_Lift, AM-Photo4all_Lift:AM-Photo4all_Lift:1042242
In: Livello 1
Type - Material: Logo-Verde
Type - Altro - Categoria: Attrezzatura meccanica; Nome famiglia: AM-Photo4all_Lift
Type - Dati identità - Nome del tipo: AM-Photo4all_Lift; Numero OmniClass: 23.75.50.17.17; Titolo OmniClass: Electronic Air Cleaners; URL: https://www.refineair.it/prodotti/
Type - Meccanica - Classificazione: Nessuno
Type - Vincoli - Prospetto di default: 2000 mm
Material: Logo-Verde, Logo-Blu, ABS, Plastica_Nera, PVC, Plastica_Bianca, Lampada, Catalizzatore, Lamiera_Grigia, Acciaio_zincato, Lamiera_Bianca, Filtro_TiO2, Ingombro
Pset_DistributionFlowElementCommon - Reference: AM-Photo4all_Lift; sets with these values: 2
Altro - Famiglia: AM-Photo4all_Lift: AM-Photo4all_Lift; Famiglia e tipo: AM-Photo4all_Lift: AM-Photo4all_Lift; ID tipo: AM-Photo4all_Lift: AM-Photo4all_Lift; TAGLI: yes; Tipo: AM-Photo4all_Lift: AM-Photo4all_Lift
Costruzione - Peso: 5 kg; Portata: 0.0202778 m3/s; Potenza sonora max dB(A): 35
Dati - Certificazioni txt: https://www.refineair.it/wp-content/uploads/2022/09/depliant-photo-familyv3_compressed.pdf; LOD: F; Manuale manutenzione txt: https://www.refineair.it/wp-content/uploads/2022/09/depliant-photo-familyv3_compressed.pdf; Manuale uso txt: https://www.refineair.it/wp-content/uploads/2022/09/depliant-photo-familyv3_compressed.pdf; TABELLA: Photo4all_Lift
Dati identità - Codice prodotto: PH4A-G-LT; Modellato da: Iperboole srl; Nome prodotto: PHOTO4ALL-LIFT; Prodotto da: Refineair
Dimensioni - Altezza: 90 mm; Area: 1.41935 m2; Larghezza: 380 mm; Profondita: 90 mm; Volume: 0.267367 m3
Elettrico - Fasi: 1; Frequenza: 50 Hz; IN: 0.1 A; Lampada_IN: 0.064 A; Lampada_Potenza: 9.8 W; Lampada_Tensione: 219 V; Potenza assorbita: 14 W; Tensione corrente: 230 V
Fasi - Fase di creazione: Nuova costruzione
Meccanica - Classificazione sistema: Alimentazione,Dati
Vincoli - Host: Livello : Livello 1; Livello: Livello: Livello 1; Offset da host: 0 mm; Quota altimetrica da livello: 0 mm
Visibilità - Componenti_interne: yes; Ingombro: yes; Supporti: yes
